# Keil uVision project Template.uvprojx, settings and files
target Template (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\OLED;..\HARDWARE\TIMER;..\HARDWARE\GPIO;..\HARDWARE\ADC;..\HARDWARE\BIANMAQI;..\HARDWARE\HUIDU;..\HARDWARE\DUOJI;..\HARDWARE\PID;..\HARDWARE\Frie_Computer;..\HARDWARE\MONI;..\HARDWARE\CHAOSHENG;..\HARDWARE\IIC;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BIANMAQI/: bianmaqi.c
    ../HARDWARE/HUIDU/: huidu.c
    ../HARDWARE/DUOJI/: duoji.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/Frie_Computer/: Frie_Computer.c
    ../HARDWARE/MONI/: moni.c
    ../HARDWARE/CHAOSHENG/: chaoshengbo.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/: mpu6050.c
